<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>one_qubit_simultor_SDR</value></param>
<param><key>author</key><value>Noritsuna Imamura(noritsuna@siprop.org)</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Simple 1Qubit Simultor with SDR</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>quantum_controllers_Coprocessor</key>
<param><key>id</key><value>quantum_controllers_Coprocessor_0</value></param>
<param><key>H_freq</key><value>0</value></param>
<param><key>INIT_freq</key><value>0</value></param>
<param><key>RO_freq</key><value>0</value></param>
<param><key>S_freq</key><value>0</value></param>
<param><key>T_freq</key><value>0</value></param>
<param><key>X_freq</key><value>0</value></param>
<param><key>Y_freq</key><value>0</value></param>
<param><key>Z_freq</key><value>0</value></param>
<param><key>H_I_amp</key><value>0</value></param>
<param><key>INIT_I_amp</key><value>0</value></param>
<param><key>RO_I_amp</key><value>0</value></param>
<param><key>S_I_amp</key><value>0</value></param>
<param><key>T_I_amp</key><value>0</value></param>
<param><key>X_I_amp</key><value>0</value></param>
<param><key>Y_I_amp</key><value>0</value></param>
<param><key>Z_I_amp</key><value>0</value></param>
<param><key>H_I_bw</key><value>0</value></param>
<param><key>INIT_I_bw</key><value>0</value></param>
<param><key>RO_I_bw</key><value>0</value></param>
<param><key>S_I_bw</key><value>0</value></param>
<param><key>T_I_bw</key><value>0</value></param>
<param><key>X_I_bw</key><value>0</value></param>
<param><key>Y_I_bw</key><value>0</value></param>
<param><key>Z_I_bw</key><value>0</value></param>
<param><key>H_proc_time</key><value>0</value></param>
<param><key>INIT_proc_time</key><value>0</value></param>
<param><key>RO_proc_time</key><value>0</value></param>
<param><key>S_proc_time</key><value>0</value></param>
<param><key>T_proc_time</key><value>0</value></param>
<param><key>X_proc_time</key><value>0</value></param>
<param><key>Y_proc_time</key><value>0</value></param>
<param><key>Z_proc_time</key><value>0</value></param>
<param><key>H_Q_amp</key><value>0</value></param>
<param><key>INIT_Q_amp</key><value>0</value></param>
<param><key>RO_Q_amp</key><value>0</value></param>
<param><key>S_Q_amp</key><value>0</value></param>
<param><key>T_Q_amp</key><value>0</value></param>
<param><key>X_Q_amp</key><value>0</value></param>
<param><key>Y_Q_amp</key><value>0</value></param>
<param><key>Z_Q_amp</key><value>0</value></param>
<param><key>H_Q_bw</key><value>0</value></param>
<param><key>INIT_Q_bw</key><value>0</value></param>
<param><key>RO_Q_bw</key><value>0</value></param>
<param><key>S_Q_bw</key><value>0</value></param>
<param><key>T_Q_bw</key><value>0</value></param>
<param><key>X_Q_bw</key><value>0</value></param>
<param><key>Y_Q_bw</key><value>0</value></param>
<param><key>Z_Q_bw</key><value>0</value></param>
<param><key>qubit_id</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>showSyncPort</key><value>True</value></param>
<param><key>scale_rate</key><value>1.0</value></param>
</block>
<block>
<key>quantum_controllers_Initializer</key>
<param><key>id</key><value>quantum_controllers_Initializer_0</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>I_amp</key><value>1.0</value></param>
<param><key>I_bw</key><value>1</value></param>
<param><key>proc_time</key><value>10000</value></param>
<param><key>Q_amp</key><value>1.0</value></param>
<param><key>Q_bw</key><value>1</value></param>
<param><key>qubit_id</key><value>1</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>showWAVEports</key><value>True</value></param>
</block>
<block>
<key>quantum_controllers_Simulator</key>
<param><key>id</key><value>quantum_controllers_Simulator_0</value></param>
<param><key>center_RF</key><value>1000</value></param>
<param><key>qubit_num</key><value>1</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>showSyncPort</key><value>True</value></param>
<param><key>scale_rate</key><value>1.0</value></param>
</block>
<block>
<key>quantum_controllers_readout</key>
<param><key>id</key><value>quantum_controllers_readout_0</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>I_amp</key><value>1.0</value></param>
<param><key>I_bw</key><value>1</value></param>
<param><key>proc_time</key><value>10000</value></param>
<param><key>Q_amp</key><value>1.0</value></param>
<param><key>Q_bw</key><value>1</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>showWAVEports</key><value>True</value></param>
</block>
<block>
<key>quantum_gates_X</key>
<param><key>id</key><value>quantum_gates_X_0</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>I_amp</key><value>1.0</value></param>
<param><key>I_bw</key><value>1</value></param>
<param><key>proc_time</key><value>10000</value></param>
<param><key>Q_amp</key><value>1.0</value></param>
<param><key>Q_bw</key><value>1</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>showWAVEports</key><value>True</value></param>
</block>
<block>
<key>quantum_measurements_Detector</key>
<param><key>id</key><value>quantum_measurements_Detector_0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>showWAVEport</key><value>True</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>0</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_1</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>0</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>0</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_1</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>0</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>quantum_controllers_Coprocessor_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>quantum_controllers_Coprocessor_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>quantum_controllers_Coprocessor_0</source_block_id><sink_block_id>uhd_usrp_sink_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>quantum_controllers_Initializer_0</source_block_id><sink_block_id>quantum_gates_X_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>quantum_controllers_Simulator_0</source_block_id><sink_block_id>quantum_measurements_Detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>quantum_controllers_readout_0</source_block_id><sink_block_id>quantum_controllers_Coprocessor_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>quantum_gates_X_0</source_block_id><sink_block_id>quantum_controllers_readout_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>quantum_measurements_Detector_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>result</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>quantum_controllers_Simulator_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>quantum_controllers_Simulator_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>quantum_controllers_Simulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
